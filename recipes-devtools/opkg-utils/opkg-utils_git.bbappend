FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-busybox-ar-no-deterministic-archives.patch"


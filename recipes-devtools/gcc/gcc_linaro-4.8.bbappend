FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://0001-gcc_bz49718_no_instrument_function.patch \
"

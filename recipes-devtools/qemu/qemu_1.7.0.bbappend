FILESEXTRAPATHS_append := "${THISDIR}/files:"
SRC_URI_append_daisy =" file://qemu-escape-left-brace.patch \
                        file://qemu-ucontext.patch"

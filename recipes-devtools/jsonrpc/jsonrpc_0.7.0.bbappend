FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"
SRC_URI_append ="file://0001-jsonrpc-ipv6.patch"

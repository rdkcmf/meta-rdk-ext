FILESEXTRAPATHS_append := "${THISDIR}/files:"
SRC_URI_append_daisy =" file://0000-escape-left-brace.patch"

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " file://0002-Remove-grpc-certs.patch \
            "



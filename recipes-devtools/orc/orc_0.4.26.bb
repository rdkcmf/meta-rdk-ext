require orc.inc

PR = "${INC_PR}.0"

SRC_URI[orc.md5sum] = "8e9bef677bae289d3324d81c337a4507"
SRC_URI[orc.sha256sum] = "7d52fa80ef84988359c3434e1eea302d077a08987abdde6905678ebcad4fa649"


FILESEXTRAPATHS_append := "${THISDIR}/files:"

SRC_URI_append = " file://create_stackwalk_common_target.patch "

CFLAGS_append_morty = " -Wno-implicit-fallthrough"

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://header_installation.patch"

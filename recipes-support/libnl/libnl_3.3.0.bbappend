FILESEXTRAPATHS_append := "${THISDIR}/files:"

SRC_URI += " \
        file://libnl-fix-issue-with-bridge-nlink.patch \
"


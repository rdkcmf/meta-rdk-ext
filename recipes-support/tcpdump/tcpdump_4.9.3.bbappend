FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://CVE-2018-16301.patch \
            file://CVE-2020-8037.patch"

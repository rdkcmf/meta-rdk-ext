# pcre16 support is needed for Qt5.1.1 (--system-pcre)
EXTRA_OECONF += "--enable-pcre16"

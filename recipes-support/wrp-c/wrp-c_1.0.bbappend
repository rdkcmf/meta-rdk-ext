FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-RDK-27629-wrp-c-build-failure-with-Werror-stringop-t.patch"


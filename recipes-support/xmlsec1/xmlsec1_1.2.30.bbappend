FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append_dunfell += " file://0002-fix-openssl-err-string-initialisation.patch \
                          "


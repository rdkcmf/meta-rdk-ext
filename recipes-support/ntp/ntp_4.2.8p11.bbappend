FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://disable_pthread_warmup.patch \
           "

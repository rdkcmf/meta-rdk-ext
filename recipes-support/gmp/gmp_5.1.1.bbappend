EXTRA_OECONF += " --disable-assembly"

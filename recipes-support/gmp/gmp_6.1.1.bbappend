do_install_append_morty() {
        #rm -f ${D}${libdir}/libgmp.so*
}


DEPENDS_remove = "swig"

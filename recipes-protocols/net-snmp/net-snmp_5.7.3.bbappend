FILESEXTRAPATHS_prepend := "${THISDIR}/${BP}:"
SRC_URI += "file://rdk_enhancement.patch"

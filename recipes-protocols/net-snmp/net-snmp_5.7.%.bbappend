
FILESEXTRAPATHS_prepend := "${THISDIR}/${BP}:"
SRC_URI += "file://net-snmp-5.7.2-fix-CVE-2018-1000116.patch"



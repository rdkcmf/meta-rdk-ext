#Linking atomic for mipsel platforms.
FINAL_LIBS_mipsel = "-latomic"

RDEPENDS_${PN}_append = " webkitbrowser-plugin"

PACKAGES += "${PN}-repair"

FILES_${PN}-repair += "${base_sbindir}/xfs_repair"

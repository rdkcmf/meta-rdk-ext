# NOTE: please remove this when upgrading to gstreamer 1.16+

RDEPENDS_gstreamer1.0-meta-base_remove_dunfell = "gstreamer1.0-plugins-good-soup"
RDEPENDS_gstreamer1.0-meta-base_append_dunfell = " gstreamer1.0-plugins-good-souphttpsrc"


FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " \
        file://libpng-1.6.28-apng.patch \
        "


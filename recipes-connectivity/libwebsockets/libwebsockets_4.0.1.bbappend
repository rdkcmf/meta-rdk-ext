FILESEXTRAPATHS_append := "${THISDIR}/files:"
SRC_URI_append =" file://lws_extension_callback.patch"

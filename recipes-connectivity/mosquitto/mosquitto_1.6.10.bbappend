PACKAGECONFIG_remove = " websockets"


SRC_URI_remove = "file://0001-TCXB6-9394-Modify-default-cipher-list-to-include-3DE.patch"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-DELIA-31053-increase-rescan-timeout.patch"


PACKAGECONFIG_append = " brotli"
PACKAGECONFIG[brotli] = "--with-brotli,--without-brotli,brotli"

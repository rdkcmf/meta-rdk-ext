do_install_append_dunfell() {
        rm ${D}${bindir}/rdkbrowser2-control
}
do_install_append() {
    rm -f ${D}${libdir}/libbrotlienc.*
}

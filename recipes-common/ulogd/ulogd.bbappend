FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://remove_unused_config.patch"

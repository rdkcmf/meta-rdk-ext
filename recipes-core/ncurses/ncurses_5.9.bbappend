FILESEXTRAPATHS_append := "${THISDIR}/files:"
SRC_URI_append_daisy =" file://0001-Fix-errors-in-type-conversion.patch"

FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"
SRC_URI_append_mipsel = " file://util-linux-2.24.1.diff "

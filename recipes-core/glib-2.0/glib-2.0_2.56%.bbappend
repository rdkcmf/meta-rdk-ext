SRC_URI_append = " \
           file://happy_eyeballs_v0_2.56.patch \
           "

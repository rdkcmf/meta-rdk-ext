stblinux_5%.bbappend